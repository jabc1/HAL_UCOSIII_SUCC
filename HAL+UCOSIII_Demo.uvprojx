# Keil uVision project HAL+UCOSIII_Demo.uvprojx, settings and files
target HAL+UCOSIII_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HAL_Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xE,USE_HAL_DRIVER
  c include: .\App;.\CMSIS;.\Core;.\HAL_lib\STM32F1xx_HAL_Driver\Inc;.\HAL_lib\STM32F1xx_HAL_Driver\Inc\Legacy;.\User;.\Sys;.\Task;.\UCOSIII\OS;.\UCOSIII\uC-CPU;.\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;.\UCOSIII\uC-LIB;.\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\UCOSIII\UCOS-BSP;.\UCOSIII\uCOS-III\Source;.\UCOSIII\uCOS-III\Ports;.\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ./Core/: core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h cmsis_armcc.h
  group HAL_lib
    ./HAL_lib/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group CMSIS
    ./CMSIS/: startup_stm32f103xe.s stm32f1xx.h system_stm32f1xx.h re_def.h
  group User
    ./User/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_conf.h stm32f1xx_it.h
  group Sys
    ./Sys/: urat.c urat.h
  group App
    ./App/: gpio.c gpio.h sys.c sys.h init.c init.h
  group Task
    ./Task/: mytask.c mytask.h
  group UCOS_CPU
    ./UCOSIII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ./UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group UCOS_LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ./UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII
    ./UCOSIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ./UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOS_CONFIG
    ./UCOSIII/OS/: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOS_BSP
    ./UCOSIII/UCOS-BSP/: bsp.c bsp.h
  group ReadMe
    ./: ReadMe.txt
